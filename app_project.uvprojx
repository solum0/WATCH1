# Keil uVision project app_project.uvprojx, settings and files
target APP Target (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: fromelf --bin --output=.\Objects\APP\app.bin .\Objects\APP\app.axf
  AfterMake: python .\Bootloader\make_update_package.py
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__FPU_USED=1,APP_BUILD
  c misc: --no-multibyte-chars
  c include: .\CMSIS;.\Library\inc;.\Library\src;.\Start;.\Objects;.\freertos\include;.\freertos\portable\ARM_CM4F;.\freertos\portable\MemMang;.\freertos\RTOS;.\freertos\source;.\User\EM7028;.\User\Battery;.\User\BME280;.\User\DS3231;.\User\KEY;.\User\MOTOR;.\User\MPU6050;.\User\OLED;.\User\TIM;.\User\UART;.\User;.\Bootloader;.\User\MCU_Debug
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ./CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group Library//inc
    ./Library/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dfsdm.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_dsi.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_lptim.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group Library/src
    ./Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Start
    ./Start/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h startup_stm32f411xe.s
  group User
    ./User/: main.c boot_confirm.c boot_confirm.h ota_update.c ota_update.h delay.c i2c.c max30102.c delay.h i2c.h max30102.h hi2c.c hi2c.h app_version.h
  group freertos/portable
    ./freertos/portable/ARM_CM4F/: port.c portmacro.h
    ./freertos/portable/MemMang/: heap_4.c
  group freertos/include
    ./freertos/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/RTOS
    ./freertos/RTOS/: FreeRTOSConfig.h
  group freertos/source
    ./freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group User/EM7028
    ./User/EM7028/: EM7028.c EM7028.h HrAlgorythm.c HrAlgorythm.h libBp.lib libBpm.lib user_Queue.c user_Queue.h
  group User/Battery
    ./User/Battery/: ADC_battery.c ADC_battery.h
  group User/BME280
    ./User/BME280/: bme280.c bme280.h
  group User/DS3231
    ./User/DS3231/: ds3231.c ds3231.h
  group User/KEY
    ./User/KEY/: Key.c Key.h
  group User/MOTOR
    ./User/MOTOR/: motor.c motor.h
  group User/MPU6050
    ./User/MPU6050/: mpu6050.c mpu6050.h
  group User/OLED
    ./User/OLED/: OLED.c OLED.h oled_clock.c oled_clock.h OLED_Data.c OLED_Data.h oled_font.c oled_font.h
  group User/TIM
    ./User/TIM/: timer.c timer.h
  group User/UART
    ./User/UART/: usart.c usart.h
  group User/MCU_Debug
    ./User/MCU_Debug/: MCU_Debug.c MCU_Debug.h
