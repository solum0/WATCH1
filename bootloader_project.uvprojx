# Keil uVision project bootloader_project.uvprojx, settings and files
target Bootloader Target (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: fromelf --bin --output=.\Objects\Bootloader\bootloader.bin .\Objects\Bootloader\bootloader.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__FPU_USED=1,BOOTLOADER_BUILD
  c misc: --no-multibyte-chars
  c include: .\CMSIS;.\Library\inc;.\Library\src;.\Start;.\Objects;.\freertos\include;.\freertos\portable\ARM_CM4F;.\freertos\portable\MemMang;.\freertos\RTOS;.\freertos\source;.\User\EM7028;.\User\Battery;.\User\BME280;.\User\DS3231;.\User\KEY;.\User\MOTOR;.\User\MPU6050;.\User\OLED;.\User\TIM;.\User\UART;.\User;.\Bootloader;.\User\MCU_Debug
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ./CMSIS/: system_stm32f4xx.c stm32f4xx_it.c
  group Start
    ./Start/: startup_stm32f411xe.s
  group Bootloader
    ./Bootloader/: boot_main.c
  group Library/src
    ./Library/src/: stm32f4xx_flash.c
